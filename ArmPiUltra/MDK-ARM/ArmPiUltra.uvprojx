# Keil uVision project ArmPiUltra.uvprojx, settings and files
target ArmPiUltra (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ArmPiUltra +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hiwonder/Peripherals/Src;../Hiwonder/Portings/Src;../Hiwonder/Portings/Inc;../Hiwonder/Misc;../Hiwonder/System;../Hiwonder/Arm/Inc;../Hiwonder/Arm/src;..\Hiwonder\Chassis\Inc;..\Hiwonder\Chassis\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hiwonder/Peripherals
    ../Hiwonder/Peripherals/Src/: led.c buzzer.c serial_servo.c key.c hiwonder_err.h w25q64.c w25q64.h i2c_bus_manager.c i2c_bus_manager.h
    ../Hiwonder/Peripherals/Inc/: buzzer.h
  group Hiwonder/Portings
    ../Hiwonder/Portings/Src/: led_porting.c key_porting.c serial_servo_porting.c packet_porting.c buzzer_porting.c
  group Hiwonder/System
    ../Hiwonder/System/: battery_handle.c battery_handle.h packet_handle.c packet_reports.h
  group Hiwonder/Misc
    ../Hiwonder/Misc/: packet.h packet.c lwrb.h lwrb.c lwmem_sys.h lwmem_porting.h lwmem_porting.c lwmem_opts.h lwmem_opt.h lwmem.h lwmem.c hiwonder_err.h checksum.h checksum.c
  group Hiwonder/Arm
    ../Hiwonder/Arm/src/: LeArm.lib robot_arm.c
    ../Hiwonder/Arm/Inc/: kinematics.h robot_arm.h
software components: CMSIS:CORE 5.6.0
